# Keil uVision project stm32f10x_all.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: "E:\9. My Workspace\FW-MCU-RTT\2020_mcu-fw\Art_stm32f10x_hal\build\CopyHex_Flash.bat"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F103xB
  c include: .;rt-thread\include;applications;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;libraries\STM32F1xx_HAL\CMSIS\Include;..\rtt_user_manage;..\Drivers\bsp_mcu;..\Drivers\eeprom\at24cxx;.\board\inc_mbkbcn1;..\Drivers\Analog-to-Digital Converter\mcp3421;..\Drivers\gpio expansion\pca95xx;..\Drivers\motor controller\tmc429;..\Drivers\led_drivers\tlc5973;..\Drivers\light senosr\isl29125 rgb;.\board\inc_mbtmc429;..\Drivers\Analog-to-Digital Converter\ads1220;..\Drivers\Analog-to-Digital Converter\dmm;..\Drivers\Analog-to-Digital Converter\ad7124;.\board\INC-MBAD7124-DMM;.\board\inc_fbtmc429_idc16_rs485;.\board\cmds_dut_dummy;.\board\inc_projects
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ./rt-thread/components/finsh/: shell.c
    rt-thread/components/finsh/: msh.c symbol.c cmd.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group STM32_HAL
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
    ./libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group bsp_board_mcu_config
    ./board/: board.h rtconfig.h Kconfig
    board/: board.c
    ./board/linker_scripts/: link.sct
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    ./board/CubeMX_Config/Inc/: stm32f1xx_hal_conf.h
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ./libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    ./: SConscript
  group driver_finsh_user
    ../rtt_user_manage/: inc_msh.c inc_cmds.c inc_shell.c rtt_function_modify.c
  group driver_bsp_mcu
    ../Drivers/bsp_mcu/: bsp_mcu_delay.c bsp_mcu_gpio.c bsp_mcu_softi2c.c
  group driver_eeprom
    ../Drivers/eeprom/at24cxx/: bsp_eeprom_24xx.c app_eeprom_24xx.c
  group driver_adc
    ../Drivers/Analog-to-Digital Converter/mcp3421/: bsp_mcp3421.c
    ../Drivers/Analog-to-Digital Converter/ad7124/: ad7124.c ad7124_regs.c cal.c mbkb_ad7124_dmm.c dmm.c platform_drivers.c Communication.c
  group driver_gpio_expansion
    ../Drivers/gpio expansion/pca95xx/: bsp_pca9539a.c
    ../Drivers/gpio expansion/pca6408/: TCA6408A.c
  group driver_motor
    ./board/inc_projects/: app_motion.c
    ../Drivers/motor controller/tmc429/: app_tmc429.c TMC429.c TMCL.c
  group driver_led
    ../Drivers/led_drivers/tlc5973/: bsp_tlc5973.c
  group driver_light_rgb_mea
    ../Drivers/light senosr/isl29125 rgb/: isl29125.c
    ./board/inc_mb1616dev6/: inc_fb29125.c
  group board_mbkbcn1-02
    ./board/inc_mbkbcn1/: timer_encoder.c bsp_12BitADC.c inc_mbkbcn1.c
  group board_mbkbcn1-03
    ./board/inc_mbkbcn1_03/: bsp_12BitADC_03.c inc_mbkbcn1_03.c timer_encoder_03.c
  group board_mb1616dev6
    ./board/inc_mb1616dev6/: mb1616dev6_spi.c app_pca9539a_dido.c app_mcp3421.c inc_fbtlc5973.c tmc429_config.c inc_mb1616dev6.c
  group board_mbtmc429
    ./board/inc_mbtmc429/: app_gpio_dido.c mbtmc429_spi.c mbtmc429_timer_pwm.c mbtmc429_rtt_timer.c tmc429_config.c inc_mbtmc429.c NMEI-IN3CIDRXXN-00X.c
  group board_mbads1220-4W-R01
    ../Drivers/Analog-to-Digital Converter/ads1220/: ADS1220.c
    ./board/inc_mbads1220_4w_r/: inc_mbads1220_4w-r.c
  group dmm_cmd
    ../Drivers/Analog-to-Digital Converter/ad7124/: ad7124_app - 副本.c
    ../Drivers/Analog-to-Digital Converter/dmm/: dmm.c
  group board_fbuirmea
    ./board/inc_fbuirmea_04/: inc_fbuirmea_04.c ad7124_app.c
  group INC-MBAD7124-DMM
    ./board/INC-MBAD7124-DMM/: ad7124_dmm.c INC-MBAD7124-DMM-01.c
  group INC-FBTMC429-IDC16-RS485
    ./board/inc_fbtmc429_idc16_rs485/: INC-FBTMC429-IDC16-RS485.c
  group commands_for_debug
    ./board/cmds_dut_dummy/: cmds_dut_dummy.c
  group inc_projects
    ./board/inc_projects/: inc_projects.c
  group module-mbtmc429
    ./board/module/inc_mbtmc429/: app_gpio_dido.c app_gpio_dido.h inc_app_tmc429.c inc_app_tmc429.h inc_cmds.c inc_mbtmc429.c inc_mbtmc429.h mbtmc429_rtt_timer.c mbtmc429_rtt_timer.h mbtmc429_spi.c mbtmc429_spi.h mbtmc429_timer_pwm.c mbtmc429_timer_pwm.h NMEI-IN3CIDRXXN-00X.c tmc429_config.c
  group board_mbrelayadp_cn1
    ./board/inc_mbrelayadp_cn1/: app_eeprom_24xx.c mbrelayadp_cn1.c
  group board_mbeeprom
    ./board/inc_mbeepromwr/: mbeepromwr.c
  group docs
    ./board/: readme.c
