# Keil uVision project stm32f103xe-512-64.uvprojx, settings and files
target rt-thread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F103xE
  c include: .;rt-thread\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rtt-origin;.;rtt_user_manage;.;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;libraries\STM32F1xx_HAL\CMSIS\Include;..\..\Drivers\bsp_mcu_rtt;..\..\Drivers\bsp_mcu_rtt;..\..\Drivers\eeprom\at24cxx;..\..\Boards\inc_include;..\..\Drivers\motor controller\tmc429;..\..\Drivers\gpio expansion\pca9539;..\..\Drivers\light senosr\isl29125 rgb;..\..\Boards\inc_mbtmc429
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c user_fun_test.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group STM32_HAL
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
    ./libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group rtt_origin_manage
    rtt-origin/: origin_shell.c
  group rtt_user_manage
    rtt_user_manage/: user_shell.c rtt_function_modify.c
    ./rtt_user_manage/: user_shell_cmd.c user_commands.h user_commands.c
  group doc
    ../doc/: readme_rtt_set.txt
  group bsp_mcu
    ../../Drivers/bsp_mcu_rtt/: bsp_mcu_delay.c bsp_mcu_gpio.c bsp_mcu_softi2c.c
  group eeprom
    ../../Drivers/eeprom/at24cxx/: bsp_eeprom_24xx.c
  group tmc429
    ../../Drivers/motor controller/tmc429/: TMC262.c TMC429.c
  group pca9539
    ../../Drivers/gpio expansion/pca9539/: bsp_pca9539a.c
  group isl29125
    ../../Drivers/light senosr/isl29125 rgb/: isl29125.c
  group inc-mb1616dev6
    ../../Boards/inc_mb1616dev6/: inc_mb1616dev6.c app_gpio_dido.c app_light_sensor.c mbtmc429_cube_spi.c
    ../../Boards/inc_mbtmc429/: mbtmc429_cube_tim.c mbtmc429_cube_usart.c
  group inc-mbtmc429
    ../../Boards/inc_mbtmc429/: app_button.c app_eeprom_24xx.c app_gpio_dido.c app_serial.c app_sys_control.c app_timer.c encoder.c inc_mbtmc429.c mbtmc429_cube_gpio.c mbtmc429_cube_spi.c tmc429_motion_cmd.c
  group user_apps
    ../../Drivers/user_apps/: app_eeprom_24xx.c tmc429_motion_cmd.c motion_control.c app_button.c app_serial_pressure.c app_projects.c
